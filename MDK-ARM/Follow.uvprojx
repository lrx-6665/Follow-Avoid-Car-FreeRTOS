# Keil uVision project Follow.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Core\Inc;..\Drivers\CMSIS\CoreSupport;..\Drivers\CMSIS\Device\ST\STM32F10x\Include;..\Drivers\STM32F10x_StdPeriph_Driver\inc;..\Middlewares\Third_Party\FreeRTOS\Source\include;..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ../Drivers/CMSIS/Device/ST/STM32F10x/Source/Templates/arm/: startup_stm32f10x_md.s
    ../Drivers/CMSIS/CoreSupport/: core_cm3.c core_cm3.h
    ../Drivers/CMSIS/Device/ST/STM32F10x/Include/: stm32f10x.h system_stm32f10x.h
    ../Drivers/CMSIS/Device/ST/STM32F10x/Source/Templates/: system_stm32f10x.c
  group Library
    ../Drivers/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../Drivers/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group System
    ../Core/Src/: Delay.c sys.c
    ../Core/Inc/: Delay.h sys.h
  group User
    ../Core/Src/: main.c stm32f10x_it.c
    ../Core/Inc/: stm32f10x_conf.h stm32f10x_it.h
  group HARDWARE
    ../Core/Inc/: LED.h TB6612.h TIM4_PWM.h Follow.h Servo.h HCSR04.h mycontrol.h
    ../Core/Src/: TB6612.c TIM4_PWM.c Follow.c Servo.c HCSR04.c mycontrol.c
  group FreeRTOS
    ../Core/Inc/: FreeRTOSConfig.h car_rtos.h
    ../Core/Src/: car_rtos.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: tasks.c queue.c list.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
